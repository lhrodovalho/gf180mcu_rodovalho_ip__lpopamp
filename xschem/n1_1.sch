v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 290 -240 0 0 {name=p1 lab=D}
C {devices/iopin.sym} 290 -200 0 0 {name=p2 lab=G}
C {devices/iopin.sym} 290 -160 0 0 {name=p3 lab=S}
C {devices/iopin.sym} 290 -120 0 0 {name=p4 lab=B}
C {devices/code_shown.sym} 20 -90 0 0 {name=s1 only_toplevel=false value="
xd d g x b nfet_06v0 ad=0.54p pd=2.4u as=0.54p ps=2.4u w=5.4u l=1.8u
xs x g s b nfet_06v0 ad=0.54p pd=2.4u as=0.54p ps=2.4u w=5.4u l=1.8u
"}
